<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTOS2_TaskOperations.ewp</path>
  </project>
  <batchBuild />
</workspace>
